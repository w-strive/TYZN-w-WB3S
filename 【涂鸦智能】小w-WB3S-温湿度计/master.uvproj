# Keil uVision project master.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC8A8K64S4A12 Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x1FFF) IROM(0-0xFFF8) CLOCK(35000000) MODP2
  output: master +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\user;.\app\delay;.\app\OLED;.\app\spi;.\app\uart;.\app\key;.\app\time;.\app\eeprom;.\app\wifi;.\app\AD;.\app\i2c;.\app\DS3231;.\app\VEML6030;.\app\SHT3x
  group user
    ./user/: main.c public.h struct.h
  group app
    ./app/eeprom/: eeprom.c
    ./app/delay/: delay.c
    ./app/time/: time.c
    ./app/key/: key.c
    ./app/uart/: uart.c
    ./app/spi/: spi.c
    ./app/AD/: adc.c
    ./app/i2c/: i2c.c
  group oled
    ./app/OLED/: oled.c GUI.c font.h
  group WB3S
    ./app/wifi/: mcu_api.c mcu_api.h protocol.c protocol.h system.c system.h wifi.h readme.txt VERSION.md
  group 时钟
    ./app/DS3231/: DS3231.c
  group 环境光
    ./app/VEML6030/: veml6030.c
  group 温湿度
    ./app/SHT3x/: SHT3x.c
